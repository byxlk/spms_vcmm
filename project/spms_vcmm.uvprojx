# Keil uVision project spms_vcmm.uvprojx, settings and files
target spms_vcmm (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: spms_vcmm +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HT6x2x
  c include: ..\sourcecode\CMSIS;..\sourcecode\CMSIS\CM0\DeviceSupport\inc;..\sourcecode\CMSIS\CM0\CoreSupport;..\sourcecode\CMSIS\CM0\DeviceSupport;..\sourcecode\HT60xx_StdPeriph_Driver\inc;..\sourcecode;..\sourcecode\HT60xx_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../sourcecode/CMSIS/CM0/DeviceSupport/src/: system_ht6xxx.c
  group StdPeriphDriver
    ../sourcecode/HT60xx_StdPeriph_Driver/src/: ht6x3x_emu.c ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_crc.c ht6xxx_dma.c ht6xxx_ecc.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_iic.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_tdes&rand.c ht6xxx_timer.c ht6xxx_uart&7816.c ht50xx_emu.c ht501x_keyscan.c
  group Startup
    ../sourcecode/Startup/Keil/: startup_ht6x2x.s
  group Main
    ../sourcecode/: ht6xxx_it.c main.c
